# Keil uVision project template51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group App
    ./: main.c uart_put.c
